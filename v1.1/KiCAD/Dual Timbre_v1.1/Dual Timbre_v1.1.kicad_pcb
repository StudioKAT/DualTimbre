# Repository StudioKAT/DualTimbre

File README.md:

# Dual Timbre

## 概要 / Overview

**Dual Timbre** は、Buchlaのウェーブフォルダー回路を現代的にアレンジした、デュアル構成のサウンドシェイピングツールです。  
VCAのレスポンスカーブは、リニアからエクスポネンシャルまで連続的に調整可能です。  
TIMBREおよびOFFSETノブは、パッチケーブルが接続されていない場合にはVCAの開き具合を調整するコントロールとして機能し、CV信号が接続されている場合にはアッテネーターとして動作します。  
CV入力は0～+10V、オーディオ入力は±5V（10Vpp）を想定しています。  

**Dual Timbre** is a dual-channel sound shaping tool that offers a modern take on the Buchla wavefolder circuit.  
The VCA response curve is continuously adjustable from linear to exponential.  
The TIMBRE and OFFSET knobs act as controls for the VCA's opening amount when no patch cable is connected, and serve as attenuators when a CV signal is present.  
The CV input expects a 0 to +10V signal, while the audio input is designed for ±5V (10V peak-to-peak).  

## 仕様 / Spec
- Format: Eurorack
- Function: Buchla Style Wave Folder
- Current needs: +12V: 55mA, -12V: 55mA
- Width: 8 HP
- Depth: 35mm (including power connector)

## 動画 / Movie

v1.1 UPDATE  
https://x.com/StudioKAT_synth/status/1931323608674316583

## 販売 / Sales

StudioKATオフィシャルショップで販売しています。(日本国内限定)  
 https://www.studiokat.jp/items/109037903

## ライセンス / License

この作品は [Creative Commons 表示 - 継承 4.0 国際 (CC BY-SA 4.0)](https://creativecommons.org/licenses/by-sa/4.0/deed.ja) の下でライセンスされています。  
This work is licensed under the [Creative Commons Attribution-ShareAlike 4.0 International License](https://creativecommons.org/licenses/by-sa/4.0/).

## クレジット / Credits

- Designed by : StudioKAT
- Website : https://www.studiokat.jp/
- GitHub : https://github.com/StudioKAT
- X(Twitter) : https://x.com/StudioKAT_synth
- Instagram : https://www.instagram.com/studiokat_modular/

## 更新履歴 / Changelog

- `2025-05-28` v1.0 Release
- `2025-06-08` v1.1 Curveの向き変更

## KiCad design v1.1/KiCAD/Dual Timbre_v1.1/Dual Timbre_v1.1.kicad_pcb

Parts:
C1, C2: 100nF; C_0603_1608Metric; LCSC C14663
C3, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 100nF; C_0402_1005Metric; LCSC C1525
C4, C5: 22uF; C_0805_2012Metric; LCSC C45783
D1, D2: 1N5819WS; D_SOD-323; LCSC C64886
H1: MountingHole_FRONT; MountingHole_2.2mm_M2_ISO7380_Pad
H2: MountingHole_BACK; MountingHole_2.2mm_M2_ISO7380_Pad
H3: Panel; Panel_8HP
H4, H5, H6, H7, H8, H9, H10, H11: PH_Audio; PH_AudioJack_3.5mm_Pad
H12, H13, H14, H15, H16, H17: PH_Pot; PH_RK097_15mmKnob_Pad
J1: POWER; BoxHeader_2x05_2.54mm_Europower
J2, J3: Conn_01x07_Socket; PinSocket_1x07_P2.54mm_Vertical
J4, J5: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Vertical
R1: 1K; R_0402_1005Metric; LCSC C11702
R2: 510K; R_0402_1005Metric; LCSC C11616
U1: CJ431; SOT-23; LCSC C3113
U2, U3, U4, U5, U6: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6963
U7: SSI2164; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+12V: C7.1, C9.1, C11.1, C13.1, C15.1, C17.1, J5.1, R2.2, U2.4 (V+), U3.4 (V+), U4.4 (V+), U5.4 (V+), U6.4 (V+), U7.16 (V+)
+12V_FRONT: C1.1, C4.1, D1.1 (K), J3.1; also elsewhere on the board
-12V: C8.2, C10.2, C12.2, C14.2, C16.2, C18.1, J4.1, R1.1, U2.11 (V-), U3.11 (V-), U4.11 (V-), U5.11 (V-), U6.11 (V-), U7.9 (V-)
-12V_FRONT: C2.2, C5.2, D2.2 (A), J2.1
Audio_1_BACK: J5.5; also elsewhere on the board
Audio_1_FRONT: J3.5; also elsewhere on the board
Audio_2_BACK: J4.5; also elsewhere on the board
Audio_2_FRONT: J2.5; also elsewhere on the board
CV_1_BACK: J5.3, U7.4 (I_OUT1); also elsewhere on the board
CV_1_FRONT: J3.3; also elsewhere on the board
CV_2_BACK: J4.3, U7.13 (I_OUT4); also elsewhere on the board
CV_2_FRONT: J2.3; also elsewhere on the board
GND: C3.1, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, C12.1, C13.2, C14.1, C15.2, C16.1, C17.2, C18.2, H2.1, J4.7, J5.7, U1.1 (REF), U1.2 (K), U7.8 (GND); also elsewhere on the board
GND1: C1.2, C2.1, C4.2, C5.1, H1.1, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J2.7, J3.7; also elsewhere on the board
GND2: H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, H11.1, H12.1, H13.1, H14.1, H15.1, H16.1, H17.1
I_IN1: U7.2 (I_IN1); also elsewhere on the board
I_IN2: U7.7 (I_IN2); also elsewhere on the board
I_IN3: U7.10 (I_IN3); also elsewhere on the board
I_IN4: U7.15 (I_IN4); also elsewhere on the board
I_OUT2: U7.5 (I_OUT2); also elsewhere on the board
I_OUT3: U7.12 (I_OUT3); also elsewhere on the board
unnamed: D1.2 (A), J1.1, J1.2
unnamed: D2.1 (K), J1.9, J1.10
unnamed: R2.1, U7.1 (MODE)
OUT_1_BACK: J5.6; also elsewhere on the board
OUT_1_FRONT: J3.6; also elsewhere on the board
OUT_2_BACK: J4.6; also elsewhere on the board
OUT_2_FRONT: J2.6; also elsewhere on the board
RV3_2_FRONT: J3.2; also elsewhere on the board
RV3_3_BACK: J5.4, U7.6 (VC2); also elsewhere on the board
RV3_3_FRONT: J3.4; also elsewhere on the board
RV6_2_FRONT: J2.2; also elsewhere on the board
RV6_3_BACK: J4.4, U7.11 (VC3); also elsewhere on the board
RV6_3_FRONT: J2.4; also elsewhere on the board
Ref_-2.5V: C3.2, C6.2, R1.2, U1.3 (A); also elsewhere on the board

Parts:
C27: 47pF; C_0402_1005Metric; LCSC C1567
D3, D4: 1N4148WS; D_SOD-323; LCSC C2128
J12: TIMBRE_OUT_1; AudioJack_PJ301M-12
R25: 10K; R_0402_1005Metric; LCSC C25744
R26, R43, R45: 51K; R_0402_1005Metric; LCSC C25794
R27: 91K; R_0603_1608Metric; LCSC C23265
R28: 30K; R_0603_1608Metric; LCSC C22984
R29: 68K; R_0402_1005Metric; LCSC C36871
R30, R31, R32, R33, R34, R44: 150K; R_0402_1005Metric; LCSC C25755
R35: 100K; R_0402_1005Metric; LCSC C25741
R36: 47K; R_0402_1005Metric; LCSC C25792
R37: 470K; R_0402_1005Metric; LCSC C25790
R38: 18K; R_0402_1005Metric; LCSC C25762
R39: 75K; R_0402_1005Metric; LCSC C25798
R40: 1.5M; R_0603_1608Metric; LCSC C4172
R41: 33K; R_0402_1005Metric; LCSC C25779
R42: 240K; R_0603_1608Metric; LCSC C4197
R46: 22K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C31850
R47: 470K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23178
R48: 1K; R_0402_1005Metric; LCSC C11702
U2, U3, U4, U5: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6963

Connections:
GND: U2.3 (+), U2.5 (+), U3.3 (+), U3.5 (+), U4.3 (+), U4.5 (+), U5.3 (+), U5.5 (+); also elsewhere on the board
GND1: J12.S; also elsewhere on the board
unnamed: C27.2, D3.2 (A), D4.1 (K), R44.2, R46.1, U5.1
unnamed: C27.1, D3.1 (K), D4.2 (A), R35.2, R36.2, R37.2, R38.2, R44.1, R45.2, U5.2 (-)
unnamed: R30.1, U2.1
unnamed: R31.1, U2.7
unnamed: R32.1, U3.1
unnamed: R33.1, U3.7
unnamed: R34.1, U4.1
unnamed: R43.2, R45.1, U4.7
unnamed: R47.2, R48.1, U5.7
unnamed: R25.2, R30.2, R35.1, U2.2 (-)
unnamed: R26.2, R31.2, R36.1, R37.1, U2.6 (-)
unnamed: R27.2, R32.2, R38.1, U3.2 (-)
unnamed: R28.2, R33.2, R39.1, R40.1, U3.6 (-)
unnamed: R29.2, R34.2, R41.1, U4.2 (-)
unnamed: R39.2, R40.2, R41.2, R42.2, R43.1, U4.6 (-)
unnamed: R46.2, R47.1, U5.6 (-)
OUT_1_BACK: R48.2; also elsewhere on the board
OUT_1_FRONT: J12.T; also elsewhere on the board
VCA_1: R25.1, R26.1, R27.1, R28.1, R29.1, R42.1; also elsewhere on the board

Notes on the sheet:
(71k4)
(44k2)
OUTPUT LEVEL

Parts:
C23, C24: 2.2nF; R_0805_2012Metric; LCSC C28260
C25, C26: 100pF; C_0402_1005Metric; LCSC C1546
J9: Timbre_CV_2; AudioJack_PJ301M-12
J10: Offset_CV_2; AudioJack_PJ301M-12
J11: Audio_IN_2; AudioJack_PJ301M-12
R14, R16: 24K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23352
R15, R17: 120K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25808
R18: 43K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23172
R19, R22: 120R; R_0402_1005Metric; LCSC C25079
R20: 10M; R_0402_1005Metric; LCSC C26082
R21: 20K; R_0402_1005Metric; LCSC C25765
R23: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22975
R24: 15K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22809
RV4, RV5, RV6: B10K; Potentiometer_RV09
U6: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6963

Connections:
+12V_FRONT: R14.2, R16.2; also elsewhere on the board
Audio_2_BACK: R21.1; also elsewhere on the board
Audio_2_FRONT: J11.T; also elsewhere on the board
CV_2_BACK: C25.1, R20.2, U6.9 (-); also elsewhere on the board
CV_2_FRONT: RV4.3, RV5.3; also elsewhere on the board
GND: C23.2, C24.2, U6.10 (+), U6.12 (+); also elsewhere on the board
GND1: J9.S, J10.S, J11.S, J11.TN, R23.2, RV4.1, RV5.1; also elsewhere on the board
I_IN3: R21.2, R22.1; also elsewhere on the board
I_IN4: R18.2, R19.1; also elsewhere on the board
I_OUT3: C26.1, R24.1, U6.13 (-); also elsewhere on the board
unnamed: C23.1, R19.2
unnamed: C24.1, R22.2
unnamed: J9.T, R15.1
unnamed: J9.TN, R14.1
unnamed: J10.T, R17.1
unnamed: J10.TN, R16.1
unnamed: R15.2, RV4.2
unnamed: R17.2, RV5.2
unnamed: R23.1, RV6.3
RV6_2_FRONT: RV6.2; also elsewhere on the board
RV6_3_BACK: C25.2, U6.8; also elsewhere on the board
RV6_3_FRONT: RV6.1; also elsewhere on the board
Ref_-2.5V: R18.1, R20.1; also elsewhere on the board
VCA_2: C26.2, R24.2, U6.14; also elsewhere on the board

Notes on the sheet:
向き変更 exp→linから lin→exp
Timbre
OFFSET
CURVES
Input Gain
49.9K→43Kに変更

Parts:
C28: 47pF; C_0402_1005Metric; LCSC C1567
D5, D6: 1N4148WS; D_SOD-323; LCSC C2128
J13: TIMBRE_OUT_2; AudioJack_PJ301M-12
R49: 10K; R_0402_1005Metric; LCSC C25744
R50, R67, R69: 51K; R_0402_1005Metric; LCSC C25794
R51: 91K; R_0603_1608Metric; LCSC C23265
R52: 30K; R_0603_1608Metric; LCSC C22984
R53: 68K; R_0402_1005Metric; LCSC C36871
R54, R55, R56, R57, R58, R68: 150K; R_0402_1005Metric; LCSC C25755
R59: 100K; R_0402_1005Metric; LCSC C25741
R60: 47K; R_0402_1005Metric; LCSC C25792
R61: 470K; R_0402_1005Metric; LCSC C25790
R62: 18K; R_0402_1005Metric; LCSC C25762
R63: 75K; R_0402_1005Metric; LCSC C25798
R64: 1.5M; R_0603_1608Metric; LCSC C4172
R65: 33K; R_0402_1005Metric; LCSC C25779
R66: 240K; R_0603_1608Metric; LCSC C4197
R70: 22K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C31850
R71: 470K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23178
R72: 1K; R_0402_1005Metric; LCSC C11702
U2, U3, U4, U5: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6963

Connections:
GND: U2.10 (+), U2.12 (+), U3.10 (+), U3.12 (+), U4.10 (+), U4.12 (+), U5.10 (+), U5.12 (+); also elsewhere on the board
GND1: J13.S; also elsewhere on the board
unnamed: C28.2, D5.2 (A), D6.1 (K), R68.2, R70.1, U5.14
unnamed: C28.1, D5.1 (K), D6.2 (A), R59.2, R60.2, R61.2, R62.2, R68.1, R69.2, U5.13 (-)
unnamed: R54.1, U2.14
unnamed: R55.1, U2.8
unnamed: R56.1, U3.14
unnamed: R57.1, U3.8
unnamed: R58.1, U4.14
unnamed: R67.2, R69.1, U4.8
unnamed: R71.2, R72.1, U5.8
unnamed: R50.2, R55.2, R60.1, R61.1, U2.9 (-)
unnamed: R49.2, R54.2, R59.1, U2.13 (-)
unnamed: R52.2, R57.2, R63.1, R64.1, U3.9 (-)
unnamed: R51.2, R56.2, R62.1, U3.13 (-)
unnamed: R63.2, R64.2, R65.2, R66.2, R67.1, U4.9 (-)
unnamed: R53.2, R58.2, R65.1, U4.13 (-)
unnamed: R70.2, R71.1, U5.9 (-)
OUT_2_BACK: R72.2; also elsewhere on the board
OUT_2_FRONT: J13.T; also elsewhere on the board
VCA_2: R49.1, R50.1, R51.1, R52.1, R53.1, R66.1; also elsewhere on the board

Notes on the sheet:
OUTPUT LEVEL
(44k2)
(71k4)

Parts:
C19, C20: 2.2nF; R_0805_2012Metric; LCSC C28260
C21, C22: 100pF; C_0402_1005Metric; LCSC C1546
J6: Timbre_CV_1; AudioJack_PJ301M-12
J7: Offset_CV_1; AudioJack_PJ301M-12
J8: Audio_IN_1; AudioJack_PJ301M-12
R3, R5: 24K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23352
R4, R6: 120K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25808
R7: 43K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23172
R8, R11: 120R; R_0402_1005Metric; LCSC C25079
R9: 10M; R_0402_1005Metric; LCSC C26082
R10: 20K; R_0402_1005Metric; LCSC C25765
R12: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22975
R13: 15K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22809
RV1, RV2, RV3: B10K; Potentiometer_RV09
U6: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6963

Connections:
+12V_FRONT: R3.2, R5.2; also elsewhere on the board
Audio_1_BACK: R10.1; also elsewhere on the board
Audio_1_FRONT: J8.T; also elsewhere on the board
CV_1_BACK: C21.1, R9.2, U6.6 (-); also elsewhere on the board
CV_1_FRONT: RV1.3, RV2.3; also elsewhere on the board
GND: C19.2, C20.2, U6.3 (+), U6.5 (+); also elsewhere on the board
GND1: J6.S, J7.S, J8.S, J8.TN, R12.2, RV1.1, RV2.1; also elsewhere on the board
I_IN1: R7.2, R8.1; also elsewhere on the board
I_IN2: R10.2, R11.1; also elsewhere on the board
I_OUT2: C22.1, R13.1, U6.2 (-); also elsewhere on the board
unnamed: C19.1, R8.2
unnamed: C20.1, R11.2
unnamed: J6.T, R4.1
unnamed: J6.TN, R3.1
unnamed: J7.T, R6.1
unnamed: J7.TN, R5.1
unnamed: R4.2, RV1.2
unnamed: R6.2, RV2.2
unnamed: R12.1, RV3.3
RV3_2_FRONT: RV3.2; also elsewhere on the board
RV3_3_BACK: C21.2, U6.7; also elsewhere on the board
RV3_3_FRONT: RV3.1; also elsewhere on the board
Ref_-2.5V: R7.1, R9.1; also elsewhere on the board
VCA_1: C22.2, R13.2, U6.1; also elsewhere on the board

Notes on the sheet:
Timbre
GAIN
向き変更 exp→linから lin→exp
Input Gain
49.9K→43Kに変更
CURVES
OFFSET

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
Board: 2 copper layers, 132.1 x 128.5 mm, 149 parts (3 on the bottom side), 89 nets.

## Commit log

2025-04-30 README改行修正
2025-04-30 マニュアルJP改行修正
2025-05-28 KiCAD、画像追加
2025-05-29 動画追加
2025-06-08 v1.1 Curveの向き変更
